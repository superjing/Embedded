<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CurrentDetectionG1.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CurrentDectionG1</project>
        <configuration>Coordinator</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


